# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,PY32F030x8
  c include: ..\Drivers\CMSIS\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Drivers\BSP\PY32F030xx_Start_Kit;..\Inc;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\ltx\inc;..\ltx\components\app;..\ltx\components\debug;..\ltx\components\event_group;..\ltx\components\lock;..\ltx\components\log;..\ltx\components\script;..\Devices\Inc;..\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f030xx.s
    ../Src/: system_py32f0xx.c
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c myAPP_system.c myAPP_device_init.c myAPP_display.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_spi.c py32f0xx_hal.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c
  group ltx
    ../ltx/src/: ltx.c
    ../ltx/components/app/: ltx_app.c
    ../ltx/components/debug/: ltx_cmd.c ltx_param.c
    ../ltx/components/event_group/: ltx_event_group.c
    ../ltx/components/lock/: ltx_lock.c
    ../ltx/components/log/: ltx_log.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../ltx/components/script/: ltx_script.c
  group Devices
    ../Devices/: ST7305.c
  group Fonts
    ../Fonts/: num_trans.c colon_trans.c
software components: CMSIS:CORE 6.1.1
